# Keil uVision project AeroInfoSystem.uvproj, settings and files
target Aero_Info_System (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AeroInfoSystem +hex
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Applications;..\Drivers;..\..\..\STM32\RT-thread_1.1.1\include;..\..\..\STM32\RT-thread_1.1.1\components\finsh;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\STM32\RT-thread_1.1.1\libcpu\arm\common;..\..\..\STM32\RT-thread_1.1.1\libcpu\arm\cortex-m4;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    ../Applications/: application.c rtconfig.h GPS.c NRF24L01.c I2CSensors.c Telemetry.c
  group Startup
    ../Drivers/: board.c serial.c stm32f4xx_it.c usart.c
    ../Applications/: startup.c
  group STM32_StdPeriph
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../../STM32/RT-thread_1.1.1/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M4
    ../../../STM32/RT-thread_1.1.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../STM32/RT-thread_1.1.1/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group finsh
    ../../../STM32/RT-thread_1.1.1/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
